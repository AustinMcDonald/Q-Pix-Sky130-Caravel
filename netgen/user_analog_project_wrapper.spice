* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10] vssd2
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[7] io_analog[8] io_analog[9] io_analog[4]
+ io_analog[5] io_analog[6] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0] wbs_adr_i[10]
+ wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15] wbs_adr_i[16]
+ wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20] wbs_adr_i[21]
+ wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26] wbs_adr_i[27]
+ wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31] wbs_adr_i[3]
+ wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9] wbs_cyc_i
+ wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
X0 mosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_3/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=2e+07u
X1 mosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=2e+07u
X2 mosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=8e+06u
X3 mosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=2e+07u
X4 mosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=8e+06u
X5 mosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=2e+07u
X6 mosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=2e+07u
X7 mosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_1/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=8e+06u
X8 mosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=2e+07u
X9 mosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=2e+07u
X10 mosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=8e+06u
X11 mosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=8e+06u
X12 mosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=2e+07u
X13 mosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=8e+06u
X14 mosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=8e+06u
X15 mosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=8e+06u
X16 mosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=8e+06u
X17 mosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=8e+06u
X18 mosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=2e+07u
X19 mosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_3/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_2/PAD mosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_2/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=2e+07u
X20 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X21 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=9.44062e+14p pd=6.13881e+09u as=0p ps=0u w=5e+06u l=1e+08u
X22 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=190000u
X23 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=1e+06u
X24 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=250000u
X25 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=2e+07u
X26 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=150000u
X27 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=1e+08u
X28 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=190000u
X29 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=2e+06u
X30 vssa2 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=2e+07u
X31 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+08u
X32 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=500000u
X33 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=2e+07u
X34 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=500000u
X35 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=190000u
X36 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=1e+06u
X37 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=2e+07u
X38 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=8e+06u
X39 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=8e+06u
X40 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=500000u
X41 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=4e+06u
X42 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=150000u
X43 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=190000u
X44 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=500000u
X45 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=2e+06u
X46 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=2e+07u
X47 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=1e+08u
X48 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X49 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=2e+06u
X50 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=500000u
X51 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X52 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=2e+07u
X53 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=500000u
X54 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=2e+06u
X55 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=8e+06u
X56 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=2e+07u
X57 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=2e+06u
X58 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=4e+06u
X59 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=2e+07u
X60 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=500000u
X61 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=1e+08u
X62 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=8e+06u
X63 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=150000u
X64 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=250000u
X65 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=2e+06u
X66 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=4e+06u
X67 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=8e+06u
X68 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X69 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=4e+06u
X70 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X71 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=2e+06u
X72 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=2e+07u
X73 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=1e+06u
X74 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=8e+06u
X75 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X76 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=2e+06u
X77 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=4e+06u
X78 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=500000u
X79 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=8e+06u
X80 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=250000u
X81 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=8e+06u
X82 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=190000u
X83 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=250000u
X84 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=4e+06u
X85 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=190000u
X86 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=8e+06u
X87 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=1e+08u
X88 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=250000u
X89 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=4e+06u
X90 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=250000u
X91 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=150000u
X92 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=150000u
X93 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=250000u
X94 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=1e+06u
X95 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=2e+06u
X96 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=4e+06u
X97 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=2e+06u
X98 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=1e+06u
X99 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=190000u
X100 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=250000u
X101 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=8e+06u
X102 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=1e+06u
X103 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD vssa2 vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=1e+08u
X104 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=4e+06u
X105 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=190000u
X106 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=1e+08u
X107 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=250000u
X108 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=190000u
X109 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=1e+08u
X110 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=4e+06u
X111 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X112 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=250000u
X113 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=2e+07u
X114 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=1e+06u
X115 vssa2 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=1e+08u
X116 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=150000u
X117 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=1e+06u
X118 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=190000u
X119 mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD vssa2 sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=500000u
X120 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=350000u
X121 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_1/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=500000u
X122 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=500000u
X123 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=1e+06u
X124 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=4e+06u
X125 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=500000u
X126 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=500000u
X127 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=350000u
X128 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_1/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=2e+06u
X129 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=2e+06u
X130 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=350000u
X131 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=2e+06u
X132 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=500000u
X133 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=500000u
X134 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=2e+06u
X135 mosarray_0/pmosLVTarray1_0/a_157432_440148# mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=500000u
X136 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_1/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=4e+06u
X137 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=4e+06u
X138 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X139 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=2e+06u
X140 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=2e+06u
X141 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=4e+06u
X142 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=1e+06u
X143 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=2e+06u
X144 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=4e+06u
X145 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=350000u
X146 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=500000u
X147 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=4e+06u
X148 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=4e+06u
X149 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=2e+06u
X150 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_1/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=1e+06u
X151 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=4e+06u
X152 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=1e+06u
X153 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=2e+06u
X154 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=1e+06u
X155 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_1/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=350000u
X156 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.65e+06u l=4e+06u
X157 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=840000u l=350000u
X158 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=640000u l=350000u
X159 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=1e+06u
X160 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=4e+06u
X161 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+08u l=1e+06u
X162 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=1e+06u
X163 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=500000u
X164 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=350000u
X165 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X166 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=350000u
X167 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7e+06u l=1e+06u
X168 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=550000u l=2e+06u
X169 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_2/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_3/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_1/PAD mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_0/PAD sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=350000u
X170 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=8.37639e+14p ps=4.85167e+09u w=3e+06u l=300000u
X171 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X172 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X173 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X174 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X175 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X176 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X177 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X178 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X179 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X180 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X181 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X182 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X183 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X184 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X185 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X186 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X187 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X188 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X189 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X190 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X191 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X192 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X193 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X194 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X195 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X196 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X197 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X198 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X199 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X200 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X201 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X202 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X203 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X204 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X205 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X206 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X207 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X208 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X209 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X210 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X211 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X212 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X213 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X214 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X215 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X216 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X217 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X218 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X219 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X220 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X221 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X222 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X223 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X224 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X225 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X226 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X227 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X228 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X229 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X230 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X231 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X232 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X233 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X234 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X235 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X236 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X237 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X238 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X239 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X240 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X241 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X242 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X243 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X244 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X245 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X246 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X247 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X248 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X249 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X250 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X251 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X252 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X253 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X254 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X255 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X256 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X257 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X258 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X259 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X260 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X261 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X262 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X263 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X264 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X265 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X266 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X267 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X268 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X269 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X270 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X271 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X272 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X273 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X274 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X275 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X276 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X277 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X278 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X279 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X280 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X281 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X282 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X283 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X284 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X285 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X286 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X287 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X288 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X289 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X290 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X291 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X292 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X293 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X294 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X295 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X296 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X297 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X298 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X299 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X300 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X301 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X302 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X303 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X304 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X305 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X306 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X307 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X308 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X309 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X310 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X311 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X312 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X313 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X314 vccd1 BarePad_6/PAD BarePad_5/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X315 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X316 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X317 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X318 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X319 BarePad_5/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X320 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X321 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X322 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X323 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X324 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X325 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X326 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X327 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X328 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X329 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X330 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X331 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X332 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X333 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X334 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X335 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X336 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X337 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X338 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X339 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X340 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X341 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X342 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X343 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X344 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X345 vssa2 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X346 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X347 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X348 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X349 opamp_diego_1/vbn opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X350 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X351 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X352 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X353 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X354 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X355 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X356 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X357 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X358 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X359 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X360 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X361 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X362 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X363 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X364 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X365 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X366 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X367 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X368 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X369 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X370 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X371 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X372 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X373 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X374 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X375 vssa2 opamp_diego_1/vbn opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X376 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X377 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X378 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X379 opamp_diego_1/voe1 opamp_diego_1/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X380 BarePad_5/PAD opamp_diego_1/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X381 BarePad_5/PAD opamp_diego_1/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X382 BarePad_5/PAD opamp_diego_1/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X383 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X384 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X385 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X386 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X387 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X388 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X389 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X390 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X391 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X392 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X393 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X394 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X395 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X396 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X397 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X398 BarePad_6/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X399 vccd1 BarePad_6/PAD BarePad_6/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X400 vccd1 BarePad_6/PAD BarePad_6/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X401 BarePad_6/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X402 BarePad_6/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X403 BarePad_6/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X404 BarePad_6/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X405 BarePad_6/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X406 vccd1 BarePad_6/PAD BarePad_6/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X407 vccd1 BarePad_6/PAD BarePad_6/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X408 vccd1 BarePad_6/PAD BarePad_6/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X409 vccd1 BarePad_6/PAD BarePad_6/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X410 vccd1 BarePad_6/PAD BarePad_6/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X411 BarePad_6/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X412 BarePad_6/PAD BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X413 BarePad_5/PAD opamp_diego_1/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X414 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X415 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X416 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X417 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X418 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X419 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X420 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X421 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X422 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X423 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X424 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X425 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X426 vccd1 BarePad_6/PAD opamp_diego_1/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X427 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X428 opamp_diego_1/w_4660_n6791# BarePad_6/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X429 BarePad_5/PAD opamp_diego_1/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X430 BarePad_5/PAD opamp_diego_1/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X431 opamp_diego_1/a_10927_n7515# vccd1 opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X432 opamp_diego_1/a_10927_n7515# vccd1 opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X433 opamp_diego_1/a_10927_n7515# vccd1 opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X434 opamp_diego_1/a_10927_n7515# vccd1 opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X435 opamp_diego_1/a_10927_n7515# vccd1 opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X436 opamp_diego_1/a_10927_n7515# vccd1 opamp_diego_1/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X437 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X438 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X439 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X440 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X441 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X442 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X443 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X444 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X445 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X446 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X447 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X448 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X449 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X450 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X451 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X452 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X453 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X454 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X455 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X456 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X457 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X458 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X459 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X460 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X461 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X462 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X463 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X464 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X465 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X466 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X467 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X468 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X469 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X470 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X471 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X472 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X473 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X474 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X475 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X476 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X477 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X478 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X479 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X480 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X481 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X482 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X483 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X484 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X485 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X486 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X487 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X488 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X489 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X490 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X491 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X492 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X493 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X494 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X495 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X496 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X497 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X498 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X499 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X500 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X501 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X502 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X503 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X504 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X505 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X506 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X507 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X508 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X509 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X510 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X511 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X512 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X513 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X514 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X515 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X516 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X517 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X518 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X519 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X520 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X521 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X522 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X523 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X524 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X525 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X526 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X527 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X528 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X529 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X530 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X531 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X532 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X533 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X534 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X535 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X536 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X537 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X538 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X539 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X540 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X541 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X542 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X543 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X544 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X545 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X546 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X547 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X548 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X549 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X550 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X551 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X552 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X553 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X554 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X555 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X556 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X557 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X558 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X559 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X560 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X561 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X562 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X563 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X564 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X565 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X566 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X567 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X568 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X569 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X570 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X571 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X572 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X573 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X574 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X575 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X576 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X577 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X578 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X579 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X580 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X581 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X582 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X583 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X584 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X585 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X586 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X587 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X588 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X589 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X590 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X591 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X592 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X593 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X594 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X595 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X596 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X597 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X598 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X599 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X600 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X601 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X602 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X603 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X604 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X605 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X606 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X607 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X608 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X609 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X610 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X611 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X612 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X613 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X614 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X615 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X616 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X617 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X618 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X619 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X620 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X621 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X622 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X623 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X624 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X625 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X626 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X627 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X628 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X629 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X630 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X631 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X632 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X633 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X634 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X635 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X636 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X637 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X638 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X639 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X640 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X641 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X642 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X643 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X644 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X645 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X646 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X647 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X648 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X649 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X650 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X651 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X652 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X653 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X654 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X655 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X656 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X657 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X658 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X659 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X660 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X661 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X662 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X663 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X664 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X665 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X666 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X667 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X668 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X669 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X670 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X671 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X672 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X673 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X674 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X675 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X676 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X677 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X678 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X679 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X680 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X681 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X682 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X683 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X684 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X685 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X686 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X687 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X688 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X689 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X690 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X691 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X692 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X693 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X694 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X695 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X696 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X697 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X698 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X699 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X700 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X701 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X702 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X703 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X704 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X705 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X706 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X707 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X708 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X709 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X710 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X711 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X712 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X713 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X714 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X715 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X716 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X717 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X718 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X719 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X720 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X721 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X722 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X723 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X724 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X725 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X726 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X727 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X728 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X729 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X730 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X731 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X732 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X733 opamp_diego_1/vbn BarePad_5/PAD opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X734 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X735 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X736 opamp_diego_1/w_4660_n6791# BarePad_5/PAD opamp_diego_1/vbn opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X737 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X738 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X739 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X740 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X741 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X742 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X743 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X744 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X745 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X746 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X747 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X748 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X749 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X750 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X751 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X752 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X753 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X754 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X755 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X756 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X757 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X758 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X759 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X760 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X761 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X762 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X763 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X764 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X765 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X766 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X767 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X768 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X769 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X770 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X771 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X772 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X773 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X774 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X775 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X776 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X777 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X778 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X779 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X780 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X781 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X782 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X783 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X784 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X785 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X786 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X787 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X788 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X789 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X790 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X791 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X792 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X793 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X794 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X795 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X796 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X797 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X798 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X799 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X800 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X801 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X802 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X803 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X804 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X805 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X806 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X807 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X808 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X809 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X810 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X811 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X812 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X813 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X814 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X815 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X816 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X817 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X818 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X819 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X820 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X821 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X822 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X823 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X824 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X825 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X826 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X827 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X828 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X829 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X830 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X831 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X832 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X833 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X834 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X835 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X836 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X837 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X838 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X839 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X840 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X841 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X842 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X843 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X844 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X845 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X846 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X847 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X848 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X849 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X850 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X851 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X852 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X853 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X854 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X855 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X856 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X857 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X858 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X859 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X860 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X861 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X862 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X863 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X864 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X865 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X866 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X867 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X868 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X869 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X870 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X871 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X872 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X873 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X874 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X875 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X876 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X877 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X878 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X879 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X880 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X881 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X882 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X883 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X884 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X885 BarePad_5/PAD opamp_diego_1/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X886 vssa2 opamp_diego_1/voe1 BarePad_5/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X887 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X888 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X889 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X890 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X891 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X892 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X893 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X894 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X895 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X896 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X897 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X898 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X899 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X900 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X901 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X902 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X903 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X904 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X905 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X906 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X907 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X908 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X909 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X910 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X911 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X912 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X913 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X914 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X915 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X916 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X917 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X918 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X919 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X920 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X921 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X922 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X923 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X924 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X925 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X926 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X927 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X928 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X929 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X930 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X931 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X932 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X933 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X934 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X935 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X936 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X937 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X938 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X939 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X940 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X941 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X942 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X943 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X944 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X945 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X946 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X947 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X948 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X949 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X950 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X951 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X952 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X953 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X954 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X955 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X956 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X957 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X958 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X959 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X960 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X961 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X962 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X963 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X964 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X965 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X966 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X967 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X968 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X969 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X970 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X971 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X972 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X973 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X974 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X975 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X976 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X977 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X978 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X979 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X980 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X981 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X982 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X983 opamp_diego_1/voe1 opamp_diego_1/vin_p opamp_diego_1/w_4660_n6791# opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X984 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X985 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X986 opamp_diego_1/w_4660_n6791# opamp_diego_1/vin_p opamp_diego_1/voe1 opamp_diego_1/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X987 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X988 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X989 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X990 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X991 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X992 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X993 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X994 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X995 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X996 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X997 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X998 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X999 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1000 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1001 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1002 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1003 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1004 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1005 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1006 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1007 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1008 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1009 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1010 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1011 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1012 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1013 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1014 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1015 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1016 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1017 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1018 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1019 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1020 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1021 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1022 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1023 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1024 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1025 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1026 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1027 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1028 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1029 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1030 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1031 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1032 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1033 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1034 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1035 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1036 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1037 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1038 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1039 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1040 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1041 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1042 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1043 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1044 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1045 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1046 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1047 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1048 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1049 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1050 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1051 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1052 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1053 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1054 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1055 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1056 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1057 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1058 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1059 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1060 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1061 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1062 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1063 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1064 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1065 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1066 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1067 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1068 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1069 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1070 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1071 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1072 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1073 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1074 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1075 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1076 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1077 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1078 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1079 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1080 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1081 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1082 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1083 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1084 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1085 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1086 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1087 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1088 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1089 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1090 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1091 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1092 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1093 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1094 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1095 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1096 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1097 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1098 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1099 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1100 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1101 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1102 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1103 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1104 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1105 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1106 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1107 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1108 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1109 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1110 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1111 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1112 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1113 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1114 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1115 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1116 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1117 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1118 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1119 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1120 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1121 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1122 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1123 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1124 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1125 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1126 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1127 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1128 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1129 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1130 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1131 vccd1 BarePad_4/PAD BarePad_0/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1132 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1133 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1134 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1135 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1136 BarePad_0/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1137 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1138 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1139 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1140 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1141 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1142 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1143 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1144 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1145 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1146 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1147 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1148 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1149 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1150 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1151 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1152 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1153 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1154 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1155 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1156 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1157 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1158 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1159 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1160 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1161 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1162 vssa2 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1163 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1164 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1165 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1166 opamp_diego_0/vbn opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1167 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1168 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1169 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1170 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1171 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1172 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1173 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1174 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1175 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1176 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1177 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1178 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1179 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1180 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1181 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1182 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1183 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1184 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1185 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1186 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1187 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1188 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1189 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1190 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1191 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1192 vssa2 opamp_diego_0/vbn opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1193 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1194 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1195 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1196 opamp_diego_0/voe1 opamp_diego_0/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1197 BarePad_0/PAD opamp_diego_0/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X1198 BarePad_0/PAD opamp_diego_0/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X1199 BarePad_0/PAD opamp_diego_0/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X1200 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1201 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1202 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1203 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1204 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1205 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1206 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1207 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1208 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1209 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1210 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1211 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1212 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1213 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1214 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1215 BarePad_4/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1216 vccd1 BarePad_4/PAD BarePad_4/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1217 vccd1 BarePad_4/PAD BarePad_4/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1218 BarePad_4/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1219 BarePad_4/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1220 BarePad_4/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1221 BarePad_4/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1222 BarePad_4/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1223 vccd1 BarePad_4/PAD BarePad_4/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1224 vccd1 BarePad_4/PAD BarePad_4/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1225 vccd1 BarePad_4/PAD BarePad_4/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1226 vccd1 BarePad_4/PAD BarePad_4/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1227 vccd1 BarePad_4/PAD BarePad_4/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1228 BarePad_4/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1229 BarePad_4/PAD BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1230 BarePad_0/PAD opamp_diego_0/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X1231 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1232 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1233 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1234 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1235 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1236 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1237 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1238 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1239 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1240 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1241 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1242 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1243 vccd1 BarePad_4/PAD opamp_diego_0/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1244 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1245 opamp_diego_0/w_4660_n6791# BarePad_4/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1246 BarePad_0/PAD opamp_diego_0/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X1247 BarePad_0/PAD opamp_diego_0/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X1248 opamp_diego_0/a_10927_n7515# vccd1 opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X1249 opamp_diego_0/a_10927_n7515# vccd1 opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X1250 opamp_diego_0/a_10927_n7515# vccd1 opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X1251 opamp_diego_0/a_10927_n7515# vccd1 opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X1252 opamp_diego_0/a_10927_n7515# vccd1 opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X1253 opamp_diego_0/a_10927_n7515# vccd1 opamp_diego_0/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X1254 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1255 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1256 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1257 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1258 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1259 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1260 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1261 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1262 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1263 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1264 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1265 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1266 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1267 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1268 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1269 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1270 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1271 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1272 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1273 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1274 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1275 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1276 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1277 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1278 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1279 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1280 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1281 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1282 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1283 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1284 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1285 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1286 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1287 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1288 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1289 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1290 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1291 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1292 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1293 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1294 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1295 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1296 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1297 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1298 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1299 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1300 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1301 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1302 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1303 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1304 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1305 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1306 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1307 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1308 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1309 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1310 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1311 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1312 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1313 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1314 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1315 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1316 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1317 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1318 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1319 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1320 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1321 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1322 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1323 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1324 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1325 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1326 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1327 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1328 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1329 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1330 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1331 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1332 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1333 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1334 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1335 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1336 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1337 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1338 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1339 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1340 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1341 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1342 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1343 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1344 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1345 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1346 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1347 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1348 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1349 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1350 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1351 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1352 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1353 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1354 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1355 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1356 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1357 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1358 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1359 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1360 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1361 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1362 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1363 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1364 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1365 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1366 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1367 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1368 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1369 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1370 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1371 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1372 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1373 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1374 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1375 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1376 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1377 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1378 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1379 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1380 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1381 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1382 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1383 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1384 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1385 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1386 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1387 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1388 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1389 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1390 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1391 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1392 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1393 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1394 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1395 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1396 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1397 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1398 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1399 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1400 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1401 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1402 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1403 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1404 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1405 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1406 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1407 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1408 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1409 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1410 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1411 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1412 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1413 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1414 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1415 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1416 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1417 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1418 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1419 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1420 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1421 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1422 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1423 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1424 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1425 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1426 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1427 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1428 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1429 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1430 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1431 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1432 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1433 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1434 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1435 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1436 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1437 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1438 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1439 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1440 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1441 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1442 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1443 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1444 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1445 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1446 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1447 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1448 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1449 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1450 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1451 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1452 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1453 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1454 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1455 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1456 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1457 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1458 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1459 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1460 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1461 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1462 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1463 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1464 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1465 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1466 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1467 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1468 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1469 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1470 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1471 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1472 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1473 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1474 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1475 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1476 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1477 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1478 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1479 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1480 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1481 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1482 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1483 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1484 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1485 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1486 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1487 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1488 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1489 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1490 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1491 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1492 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1493 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1494 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1495 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1496 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1497 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1498 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1499 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1500 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1501 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1502 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1503 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1504 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1505 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1506 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1507 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1508 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1509 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1510 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1511 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1512 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1513 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1514 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1515 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1516 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1517 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1518 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1519 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1520 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1521 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1522 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1523 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1524 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1525 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1526 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1527 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1528 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1529 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1530 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1531 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1532 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1533 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1534 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1535 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1536 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1537 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1538 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1539 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1540 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1541 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1542 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1543 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1544 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1545 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1546 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1547 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1548 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1549 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1550 opamp_diego_0/vbn BarePad_0/PAD opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1551 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1552 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1553 opamp_diego_0/w_4660_n6791# BarePad_0/PAD opamp_diego_0/vbn opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1554 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1555 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1556 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1557 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1558 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1559 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1560 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1561 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1562 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1563 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1564 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1565 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1566 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1567 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1568 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1569 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1570 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1571 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1572 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1573 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1574 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1575 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1576 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1577 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1578 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1579 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1580 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1581 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1582 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1583 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1584 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1585 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1586 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1587 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1588 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1589 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1590 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1591 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1592 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1593 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1594 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1595 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1596 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1597 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1598 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1599 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1600 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1601 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1602 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1603 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1604 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1605 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1606 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1607 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1608 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1609 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1610 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1611 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1612 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1613 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1614 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1615 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1616 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1617 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1618 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1619 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1620 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1621 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1622 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1623 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1624 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1625 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1626 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1627 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1628 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1629 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1630 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1631 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1632 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1633 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1634 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1635 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1636 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1637 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1638 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1639 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1640 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1641 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1642 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1643 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1644 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1645 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1646 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1647 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1648 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1649 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1650 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1651 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1652 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1653 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1654 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1655 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1656 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1657 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1658 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1659 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1660 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1661 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1662 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1663 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1664 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1665 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1666 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1667 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1668 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1669 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1670 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1671 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1672 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1673 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1674 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1675 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1676 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1677 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1678 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1679 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1680 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1681 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1682 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1683 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1684 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1685 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1686 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1687 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1688 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1689 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1690 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1691 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1692 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1693 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1694 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1695 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1696 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1697 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1698 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1699 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1700 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1701 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1702 BarePad_0/PAD opamp_diego_0/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1703 vssa2 opamp_diego_0/voe1 BarePad_0/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X1704 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1705 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1706 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1707 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1708 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1709 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1710 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1711 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1712 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1713 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1714 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1715 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1716 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1717 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1718 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1719 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1720 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1721 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1722 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1723 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1724 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1725 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1726 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1727 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1728 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1729 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1730 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1731 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1732 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1733 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1734 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1735 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1736 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1737 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1738 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1739 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1740 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1741 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1742 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1743 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1744 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1745 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1746 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1747 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1748 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1749 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1750 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1751 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1752 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1753 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1754 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1755 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1756 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1757 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1758 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1759 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1760 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1761 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1762 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1763 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1764 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1765 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1766 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1767 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1768 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1769 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1770 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1771 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1772 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1773 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1774 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1775 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1776 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1777 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1778 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1779 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1780 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1781 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1782 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1783 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1784 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1785 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1786 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1787 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1788 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1789 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1790 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1791 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1792 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1793 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1794 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1795 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1796 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1797 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1798 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1799 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1800 opamp_diego_0/voe1 opamp_diego_0/vin_p opamp_diego_0/w_4660_n6791# opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1801 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1802 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1803 opamp_diego_0/w_4660_n6791# opamp_diego_0/vin_p opamp_diego_0/voe1 opamp_diego_0/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1804 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1805 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1806 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1807 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1808 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1809 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1810 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1811 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1812 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1813 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1814 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1815 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1816 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1817 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1818 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1819 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1820 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1821 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1822 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1823 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1824 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1825 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1826 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1827 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1828 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1829 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1830 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1831 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1832 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1833 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1834 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1835 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1836 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1837 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1838 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1839 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1840 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1841 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1842 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1843 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1844 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1845 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1846 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1847 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1848 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1849 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1850 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1851 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1852 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1853 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1854 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1855 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1856 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1857 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1858 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1859 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1860 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1861 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1862 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1863 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1864 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1865 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1866 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1867 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1868 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1869 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1870 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1871 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1872 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1873 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1874 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1875 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1876 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1877 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1878 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1879 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1880 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1881 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1882 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1883 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1884 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1885 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1886 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1887 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1888 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1889 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1890 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1891 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1892 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1893 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1894 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1895 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1896 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1897 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1898 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1899 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1900 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1901 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1902 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1903 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1904 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1905 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1906 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1907 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1908 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1909 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1910 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1911 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1912 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1913 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1914 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1915 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1916 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1917 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1918 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1919 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1920 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1921 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1922 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1923 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1924 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1925 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1926 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1927 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1928 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1929 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1930 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1931 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1932 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1933 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1934 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1935 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1936 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1937 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1938 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1939 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1940 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1941 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1942 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1943 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1944 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1945 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1946 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1947 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1948 vccd1 BarePad_10/PAD BarePad_9/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1949 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1950 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1951 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1952 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1953 BarePad_9/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1954 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1955 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1956 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1957 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1958 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1959 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1960 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1961 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1962 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1963 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1964 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1965 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1966 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1967 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1968 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1969 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1970 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1971 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1972 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1973 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1974 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1975 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1976 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1977 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1978 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1979 vssa2 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1980 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1981 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1982 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1983 opamp_diego_2/vbn opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1984 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1985 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1986 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1987 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1988 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1989 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1990 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1991 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1992 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1993 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1994 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1995 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1996 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1997 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1998 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X1999 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2000 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2001 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2002 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2003 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2004 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2005 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2006 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2007 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2008 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2009 vssa2 opamp_diego_2/vbn opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2010 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2011 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2012 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2013 opamp_diego_2/voe1 opamp_diego_2/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2014 BarePad_9/PAD opamp_diego_2/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2015 BarePad_9/PAD opamp_diego_2/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2016 BarePad_9/PAD opamp_diego_2/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2017 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2018 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2019 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2020 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2021 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2022 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2023 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2024 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2025 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2026 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2027 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2028 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2029 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2030 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2031 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2032 BarePad_10/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2033 vccd1 BarePad_10/PAD BarePad_10/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2034 vccd1 BarePad_10/PAD BarePad_10/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2035 BarePad_10/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2036 BarePad_10/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2037 BarePad_10/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2038 BarePad_10/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2039 BarePad_10/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2040 vccd1 BarePad_10/PAD BarePad_10/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2041 vccd1 BarePad_10/PAD BarePad_10/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2042 vccd1 BarePad_10/PAD BarePad_10/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2043 vccd1 BarePad_10/PAD BarePad_10/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2044 vccd1 BarePad_10/PAD BarePad_10/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2045 BarePad_10/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2046 BarePad_10/PAD BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2047 BarePad_9/PAD opamp_diego_2/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2048 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2049 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2050 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2051 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2052 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2053 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2054 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2055 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2056 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2057 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2058 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2059 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2060 vccd1 BarePad_10/PAD opamp_diego_2/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2061 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2062 opamp_diego_2/w_4660_n6791# BarePad_10/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2063 BarePad_9/PAD opamp_diego_2/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2064 BarePad_9/PAD opamp_diego_2/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2065 opamp_diego_2/a_10927_n7515# vccd1 opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2066 opamp_diego_2/a_10927_n7515# vccd1 opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2067 opamp_diego_2/a_10927_n7515# vccd1 opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2068 opamp_diego_2/a_10927_n7515# vccd1 opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2069 opamp_diego_2/a_10927_n7515# vccd1 opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2070 opamp_diego_2/a_10927_n7515# vccd1 opamp_diego_2/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2071 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2072 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2073 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2074 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2075 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2076 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2077 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2078 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2079 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2080 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2081 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2082 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2083 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2084 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2085 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2086 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2087 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2088 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2089 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2090 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2091 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2092 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2093 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2094 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2095 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2096 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2097 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2098 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2099 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2100 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2101 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2102 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2103 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2104 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2105 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2106 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2107 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2108 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2109 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2110 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2111 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2112 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2113 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2114 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2115 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2116 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2117 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2118 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2119 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2120 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2121 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2122 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2123 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2124 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2125 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2126 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2127 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2128 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2129 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2130 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2131 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2132 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2133 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2134 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2135 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2136 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2137 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2138 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2139 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2140 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2141 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2142 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2143 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2144 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2145 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2146 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2147 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2148 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2149 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2150 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2151 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2152 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2153 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2154 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2155 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2156 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2157 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2158 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2159 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2160 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2161 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2162 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2163 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2164 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2165 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2166 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2167 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2168 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2169 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2170 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2171 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2172 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2173 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2174 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2175 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2176 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2177 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2178 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2179 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2180 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2181 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2182 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2183 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2184 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2185 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2186 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2187 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2188 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2189 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2190 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2191 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2192 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2193 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2194 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2195 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2196 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2197 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2198 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2199 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2200 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2201 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2202 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2203 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2204 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2205 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2206 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2207 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2208 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2209 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2210 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2211 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2212 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2213 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2214 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2215 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2216 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2217 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2218 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2219 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2220 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2221 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2222 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2223 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2224 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2225 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2226 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2227 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2228 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2229 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2230 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2231 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2232 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2233 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2234 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2235 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2236 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2237 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2238 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2239 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2240 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2241 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2242 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2243 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2244 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2245 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2246 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2247 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2248 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2249 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2250 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2251 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2252 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2253 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2254 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2255 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2256 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2257 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2258 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2259 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2260 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2261 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2262 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2263 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2264 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2265 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2266 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2267 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2268 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2269 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2270 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2271 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2272 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2273 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2274 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2275 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2276 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2277 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2278 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2279 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2280 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2281 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2282 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2283 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2284 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2285 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2286 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2287 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2288 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2289 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2290 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2291 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2292 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2293 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2294 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2295 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2296 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2297 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2298 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2299 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2300 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2301 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2302 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2303 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2304 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2305 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2306 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2307 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2308 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2309 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2310 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2311 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2312 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2313 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2314 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2315 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2316 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2317 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2318 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2319 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2320 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2321 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2322 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2323 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2324 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2325 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2326 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2327 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2328 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2329 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2330 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2331 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2332 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2333 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2334 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2335 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2336 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2337 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2338 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2339 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2340 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2341 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2342 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2343 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2344 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2345 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2346 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2347 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2348 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2349 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2350 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2351 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2352 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2353 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2354 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2355 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2356 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2357 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2358 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2359 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2360 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2361 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2362 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2363 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2364 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2365 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2366 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2367 opamp_diego_2/vbn BarePad_9/PAD opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2368 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2369 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2370 opamp_diego_2/w_4660_n6791# BarePad_9/PAD opamp_diego_2/vbn opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2371 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2372 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2373 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2374 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2375 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2376 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2377 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2378 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2379 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2380 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2381 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2382 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2383 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2384 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2385 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2386 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2387 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2388 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2389 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2390 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2391 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2392 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2393 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2394 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2395 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2396 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2397 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2398 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2399 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2400 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2401 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2402 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2403 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2404 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2405 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2406 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2407 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2408 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2409 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2410 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2411 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2412 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2413 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2414 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2415 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2416 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2417 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2418 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2419 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2420 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2421 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2422 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2423 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2424 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2425 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2426 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2427 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2428 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2429 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2430 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2431 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2432 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2433 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2434 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2435 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2436 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2437 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2438 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2439 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2440 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2441 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2442 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2443 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2444 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2445 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2446 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2447 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2448 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2449 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2450 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2451 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2452 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2453 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2454 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2455 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2456 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2457 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2458 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2459 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2460 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2461 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2462 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2463 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2464 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2465 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2466 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2467 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2468 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2469 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2470 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2471 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2472 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2473 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2474 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2475 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2476 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2477 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2478 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2479 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2480 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2481 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2482 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2483 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2484 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2485 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2486 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2487 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2488 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2489 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2490 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2491 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2492 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2493 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2494 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2495 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2496 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2497 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2498 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2499 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2500 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2501 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2502 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2503 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2504 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2505 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2506 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2507 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2508 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2509 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2510 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2511 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2512 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2513 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2514 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2515 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2516 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2517 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2518 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2519 BarePad_9/PAD opamp_diego_2/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2520 vssa2 opamp_diego_2/voe1 BarePad_9/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X2521 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2522 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2523 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2524 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2525 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2526 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2527 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2528 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2529 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2530 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2531 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2532 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2533 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2534 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2535 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2536 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2537 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2538 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2539 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2540 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2541 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2542 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2543 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2544 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2545 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2546 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2547 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2548 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2549 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2550 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2551 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2552 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2553 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2554 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2555 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2556 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2557 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2558 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2559 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2560 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2561 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2562 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2563 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2564 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2565 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2566 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2567 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2568 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2569 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2570 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2571 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2572 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2573 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2574 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2575 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2576 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2577 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2578 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2579 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2580 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2581 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2582 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2583 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2584 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2585 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2586 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2587 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2588 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2589 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2590 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2591 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2592 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2593 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2594 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2595 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2596 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2597 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2598 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2599 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2600 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2601 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2602 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2603 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2604 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2605 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2606 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2607 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2608 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2609 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2610 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2611 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2612 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2613 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2614 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2615 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2616 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2617 opamp_diego_2/voe1 opamp_diego_2/vin_p opamp_diego_2/w_4660_n6791# opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2618 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2619 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2620 opamp_diego_2/w_4660_n6791# opamp_diego_2/vin_p opamp_diego_2/voe1 opamp_diego_2/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2621 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2622 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2623 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2624 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2625 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2626 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2627 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2628 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2629 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2630 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2631 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2632 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2633 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2634 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2635 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2636 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2637 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2638 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2639 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2640 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2641 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2642 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2643 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2644 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2645 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2646 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2647 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2648 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2649 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2650 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2651 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2652 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2653 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2654 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2655 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2656 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2657 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2658 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2659 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2660 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2661 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2662 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2663 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2664 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2665 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2666 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2667 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2668 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2669 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2670 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2671 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2672 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2673 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2674 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2675 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2676 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2677 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2678 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2679 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2680 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2681 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2682 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2683 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2684 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2685 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2686 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2687 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2688 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2689 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2690 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2691 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2692 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2693 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2694 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2695 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2696 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2697 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2698 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2699 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2700 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2701 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2702 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2703 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2704 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2705 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2706 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2707 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2708 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2709 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2710 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2711 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2712 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2713 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2714 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2715 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2716 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2717 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2718 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2719 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2720 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2721 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2722 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2723 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2724 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2725 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2726 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2727 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2728 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2729 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2730 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2731 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2732 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2733 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2734 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2735 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2736 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2737 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2738 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2739 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2740 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2741 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2742 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2743 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2744 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2745 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2746 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2747 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2748 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2749 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2750 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2751 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2752 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2753 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2754 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2755 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2756 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2757 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2758 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2759 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2760 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2761 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2762 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2763 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2764 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2765 vccd1 BarePad_14/PAD BarePad_13/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2766 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2767 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2768 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2769 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2770 BarePad_13/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2771 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2772 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2773 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2774 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2775 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2776 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2777 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2778 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2779 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2780 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2781 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2782 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2783 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2784 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2785 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2786 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2787 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2788 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2789 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2790 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2791 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2792 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2793 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2794 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2795 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2796 vssa2 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2797 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2798 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2799 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2800 opamp_diego_3/vbn opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2801 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2802 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2803 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2804 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2805 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2806 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2807 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2808 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2809 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2810 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2811 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2812 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2813 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2814 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2815 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2816 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2817 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2818 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2819 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2820 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2821 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2822 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2823 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2824 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2825 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2826 vssa2 opamp_diego_3/vbn opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2827 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2828 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2829 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2830 opamp_diego_3/voe1 opamp_diego_3/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2831 BarePad_13/PAD opamp_diego_3/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2832 BarePad_13/PAD opamp_diego_3/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2833 BarePad_13/PAD opamp_diego_3/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2834 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2835 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2836 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2837 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2838 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2839 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2840 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2841 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2842 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2843 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2844 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2845 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2846 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2847 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2848 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2849 BarePad_14/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2850 vccd1 BarePad_14/PAD BarePad_14/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2851 vccd1 BarePad_14/PAD BarePad_14/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2852 BarePad_14/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2853 BarePad_14/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2854 BarePad_14/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2855 BarePad_14/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2856 BarePad_14/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2857 vccd1 BarePad_14/PAD BarePad_14/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2858 vccd1 BarePad_14/PAD BarePad_14/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2859 vccd1 BarePad_14/PAD BarePad_14/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2860 vccd1 BarePad_14/PAD BarePad_14/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2861 vccd1 BarePad_14/PAD BarePad_14/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2862 BarePad_14/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2863 BarePad_14/PAD BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2864 BarePad_13/PAD opamp_diego_3/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2865 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2866 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2867 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2868 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2869 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2870 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2871 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2872 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2873 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2874 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2875 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2876 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2877 vccd1 BarePad_14/PAD opamp_diego_3/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2878 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2879 opamp_diego_3/w_4660_n6791# BarePad_14/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2880 BarePad_13/PAD opamp_diego_3/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2881 BarePad_13/PAD opamp_diego_3/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X2882 opamp_diego_3/a_10927_n7515# vccd1 opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2883 opamp_diego_3/a_10927_n7515# vccd1 opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2884 opamp_diego_3/a_10927_n7515# vccd1 opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2885 opamp_diego_3/a_10927_n7515# vccd1 opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2886 opamp_diego_3/a_10927_n7515# vccd1 opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2887 opamp_diego_3/a_10927_n7515# vccd1 opamp_diego_3/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X2888 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2889 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2890 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2891 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2892 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2893 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2894 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2895 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2896 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2897 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2898 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2899 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2900 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2901 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2902 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2903 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2904 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2905 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2906 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2907 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2908 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2909 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2910 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2911 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2912 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2913 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2914 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2915 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2916 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2917 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2918 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2919 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2920 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2921 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2922 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2923 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2924 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2925 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2926 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2927 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2928 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2929 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2930 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2931 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2932 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2933 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2934 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2935 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2936 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2937 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2938 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2939 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2940 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2941 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2942 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2943 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2944 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2945 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2946 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2947 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2948 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2949 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2950 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2951 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2952 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2953 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2954 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2955 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2956 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2957 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2958 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2959 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2960 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2961 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2962 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2963 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2964 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2965 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2966 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2967 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2968 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2969 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2970 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2971 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2972 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2973 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2974 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2975 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2976 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2977 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2978 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2979 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2980 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2981 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2982 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2983 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2984 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2985 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2986 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2987 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2988 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2989 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2990 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2991 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2992 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2993 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2994 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2995 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2996 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2997 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2998 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X2999 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3000 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3001 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3002 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3003 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3004 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3005 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3006 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3007 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3008 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3009 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3010 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3011 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3012 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3013 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3014 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3015 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3016 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3017 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3018 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3019 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3020 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3021 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3022 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3023 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3024 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3025 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3026 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3027 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3028 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3029 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3030 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3031 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3032 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3033 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3034 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3035 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3036 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3037 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3038 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3039 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3040 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3041 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3042 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3043 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3044 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3045 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3046 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3047 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3048 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3049 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3050 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3051 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3052 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3053 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3054 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3055 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3056 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3057 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3058 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3059 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3060 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3061 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3062 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3063 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3064 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3065 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3066 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3067 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3068 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3069 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3070 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3071 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3072 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3073 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3074 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3075 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3076 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3077 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3078 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3079 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3080 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3081 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3082 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3083 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3084 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3085 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3086 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3087 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3088 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3089 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3090 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3091 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3092 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3093 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3094 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3095 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3096 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3097 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3098 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3099 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3100 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3101 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3102 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3103 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3104 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3105 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3106 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3107 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3108 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3109 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3110 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3111 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3112 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3113 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3114 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3115 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3116 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3117 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3118 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3119 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3120 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3121 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3122 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3123 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3124 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3125 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3126 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3127 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3128 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3129 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3130 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3131 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3132 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3133 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3134 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3135 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3136 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3137 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3138 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3139 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3140 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3141 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3142 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3143 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3144 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3145 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3146 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3147 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3148 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3149 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3150 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3151 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3152 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3153 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3154 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3155 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3156 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3157 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3158 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3159 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3160 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3161 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3162 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3163 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3164 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3165 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3166 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3167 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3168 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3169 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3170 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3171 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3172 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3173 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3174 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3175 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3176 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3177 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3178 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3179 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3180 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3181 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3182 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3183 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3184 opamp_diego_3/vbn BarePad_13/PAD opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3185 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3186 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3187 opamp_diego_3/w_4660_n6791# BarePad_13/PAD opamp_diego_3/vbn opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3188 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3189 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3190 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3191 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3192 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3193 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3194 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3195 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3196 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3197 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3198 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3199 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3200 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3201 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3202 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3203 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3204 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3205 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3206 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3207 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3208 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3209 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3210 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3211 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3212 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3213 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3214 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3215 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3216 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3217 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3218 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3219 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3220 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3221 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3222 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3223 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3224 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3225 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3226 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3227 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3228 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3229 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3230 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3231 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3232 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3233 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3234 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3235 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3236 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3237 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3238 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3239 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3240 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3241 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3242 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3243 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3244 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3245 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3246 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3247 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3248 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3249 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3250 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3251 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3252 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3253 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3254 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3255 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3256 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3257 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3258 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3259 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3260 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3261 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3262 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3263 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3264 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3265 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3266 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3267 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3268 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3269 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3270 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3271 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3272 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3273 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3274 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3275 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3276 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3277 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3278 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3279 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3280 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3281 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3282 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3283 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3284 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3285 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3286 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3287 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3288 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3289 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3290 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3291 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3292 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3293 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3294 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3295 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3296 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3297 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3298 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3299 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3300 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3301 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3302 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3303 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3304 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3305 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3306 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3307 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3308 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3309 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3310 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3311 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3312 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3313 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3314 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3315 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3316 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3317 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3318 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3319 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3320 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3321 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3322 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3323 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3324 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3325 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3326 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3327 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3328 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3329 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3330 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3331 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3332 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3333 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3334 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3335 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3336 BarePad_13/PAD opamp_diego_3/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3337 vssa2 opamp_diego_3/voe1 BarePad_13/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X3338 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3339 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3340 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3341 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3342 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3343 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3344 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3345 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3346 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3347 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3348 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3349 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3350 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3351 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3352 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3353 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3354 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3355 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3356 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3357 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3358 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3359 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3360 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3361 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3362 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3363 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3364 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3365 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3366 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3367 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3368 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3369 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3370 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3371 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3372 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3373 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3374 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3375 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3376 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3377 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3378 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3379 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3380 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3381 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3382 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3383 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3384 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3385 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3386 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3387 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3388 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3389 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3390 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3391 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3392 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3393 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3394 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3395 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3396 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3397 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3398 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3399 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3400 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3401 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3402 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3403 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3404 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3405 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3406 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3407 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3408 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3409 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3410 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3411 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3412 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3413 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3414 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3415 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3416 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3417 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3418 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3419 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3420 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3421 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3422 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3423 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3424 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3425 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3426 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3427 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3428 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3429 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3430 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3431 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3432 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3433 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3434 opamp_diego_3/voe1 opamp_diego_3/vin_p opamp_diego_3/w_4660_n6791# opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3435 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3436 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3437 opamp_diego_3/w_4660_n6791# opamp_diego_3/vin_p opamp_diego_3/voe1 opamp_diego_3/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3438 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3439 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3440 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3441 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3442 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3443 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3444 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3445 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3446 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3447 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3448 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3449 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3450 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3451 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3452 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3453 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3454 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3455 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3456 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3457 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3458 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3459 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3460 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3461 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3462 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3463 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3464 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3465 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3466 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3467 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3468 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3469 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3470 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3471 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3472 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3473 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3474 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3475 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3476 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3477 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3478 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3479 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3480 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3481 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3482 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3483 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3484 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3485 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3486 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3487 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3488 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3489 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3490 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3491 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3492 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3493 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3494 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3495 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3496 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3497 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3498 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3499 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3500 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3501 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3502 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3503 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3504 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3505 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3506 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3507 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3508 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3509 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3510 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3511 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3512 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3513 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3514 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3515 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3516 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3517 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3518 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3519 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3520 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3521 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3522 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3523 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3524 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3525 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3526 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3527 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3528 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3529 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3530 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3531 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3532 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3533 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3534 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3535 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3536 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3537 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3538 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3539 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3540 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3541 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3542 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3543 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3544 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3545 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3546 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3547 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3548 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3549 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3550 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3551 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3552 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3553 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3554 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3555 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3556 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3557 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3558 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3559 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3560 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3561 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3562 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3563 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3564 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3565 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3566 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3567 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3568 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3569 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3570 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3571 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3572 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3573 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3574 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3575 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3576 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3577 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3578 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3579 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3580 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3581 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3582 vccd1 BarePad_18/PAD BarePad_17/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3583 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3584 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3585 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3586 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3587 BarePad_17/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3588 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3589 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3590 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3591 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3592 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3593 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3594 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3595 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3596 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3597 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3598 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3599 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3600 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3601 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3602 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3603 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3604 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3605 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3606 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3607 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3608 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3609 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3610 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3611 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3612 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3613 vssa2 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3614 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3615 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3616 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3617 opamp_diego_4/vbn opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3618 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3619 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3620 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3621 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3622 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3623 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3624 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3625 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3626 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3627 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3628 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3629 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3630 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3631 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3632 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3633 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3634 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3635 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3636 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3637 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3638 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3639 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3640 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3641 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3642 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3643 vssa2 opamp_diego_4/vbn opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3644 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3645 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3646 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3647 opamp_diego_4/voe1 opamp_diego_4/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3648 BarePad_17/PAD opamp_diego_4/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X3649 BarePad_17/PAD opamp_diego_4/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X3650 BarePad_17/PAD opamp_diego_4/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X3651 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3652 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3653 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3654 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3655 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3656 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3657 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3658 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3659 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3660 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3661 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3662 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3663 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3664 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3665 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3666 BarePad_18/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3667 vccd1 BarePad_18/PAD BarePad_18/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3668 vccd1 BarePad_18/PAD BarePad_18/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3669 BarePad_18/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3670 BarePad_18/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3671 BarePad_18/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3672 BarePad_18/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3673 BarePad_18/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3674 vccd1 BarePad_18/PAD BarePad_18/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3675 vccd1 BarePad_18/PAD BarePad_18/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3676 vccd1 BarePad_18/PAD BarePad_18/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3677 vccd1 BarePad_18/PAD BarePad_18/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3678 vccd1 BarePad_18/PAD BarePad_18/PAD vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3679 BarePad_18/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3680 BarePad_18/PAD BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3681 BarePad_17/PAD opamp_diego_4/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X3682 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3683 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3684 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3685 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3686 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3687 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3688 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3689 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3690 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3691 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3692 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3693 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3694 vccd1 BarePad_18/PAD opamp_diego_4/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3695 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3696 opamp_diego_4/w_4660_n6791# BarePad_18/PAD vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3697 BarePad_17/PAD opamp_diego_4/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X3698 BarePad_17/PAD opamp_diego_4/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X3699 opamp_diego_4/a_10927_n7515# vccd1 opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X3700 opamp_diego_4/a_10927_n7515# vccd1 opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X3701 opamp_diego_4/a_10927_n7515# vccd1 opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X3702 opamp_diego_4/a_10927_n7515# vccd1 opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X3703 opamp_diego_4/a_10927_n7515# vccd1 opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X3704 opamp_diego_4/a_10927_n7515# vccd1 opamp_diego_4/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X3705 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3706 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3707 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3708 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3709 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3710 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3711 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3712 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3713 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3714 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3715 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3716 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3717 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3718 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3719 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3720 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3721 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3722 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3723 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3724 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3725 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3726 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3727 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3728 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3729 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3730 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3731 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3732 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3733 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3734 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3735 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3736 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3737 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3738 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3739 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3740 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3741 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3742 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3743 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3744 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3745 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3746 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3747 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3748 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3749 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3750 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3751 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3752 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3753 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3754 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3755 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3756 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3757 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3758 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3759 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3760 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3761 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3762 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3763 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3764 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3765 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3766 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3767 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3768 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3769 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3770 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3771 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3772 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3773 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3774 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3775 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3776 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3777 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3778 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3779 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3780 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3781 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3782 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3783 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3784 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3785 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3786 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3787 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3788 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3789 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3790 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3791 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3792 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3793 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3794 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3795 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3796 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3797 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3798 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3799 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3800 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3801 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3802 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3803 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3804 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3805 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3806 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3807 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3808 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3809 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3810 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3811 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3812 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3813 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3814 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3815 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3816 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3817 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3818 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3819 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3820 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3821 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3822 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3823 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3824 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3825 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3826 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3827 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3828 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3829 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3830 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3831 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3832 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3833 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3834 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3835 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3836 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3837 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3838 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3839 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3840 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3841 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3842 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3843 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3844 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3845 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3846 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3847 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3848 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3849 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3850 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3851 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3852 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3853 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3854 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3855 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3856 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3857 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3858 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3859 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3860 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3861 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3862 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3863 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3864 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3865 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3866 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3867 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3868 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3869 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3870 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3871 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3872 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3873 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3874 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3875 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3876 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3877 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3878 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3879 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3880 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3881 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3882 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3883 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3884 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3885 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3886 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3887 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3888 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3889 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3890 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3891 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3892 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3893 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3894 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3895 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3896 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3897 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3898 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3899 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3900 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3901 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3902 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3903 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3904 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3905 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3906 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3907 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3908 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3909 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3910 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3911 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3912 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3913 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3914 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3915 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3916 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3917 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3918 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3919 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3920 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3921 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3922 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3923 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3924 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3925 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3926 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3927 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3928 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3929 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3930 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3931 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3932 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3933 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3934 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3935 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3936 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3937 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3938 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3939 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3940 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3941 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3942 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3943 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3944 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3945 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3946 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3947 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3948 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3949 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3950 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3951 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3952 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3953 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3954 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3955 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3956 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3957 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3958 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3959 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3960 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3961 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3962 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3963 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3964 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3965 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3966 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3967 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3968 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3969 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3970 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3971 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3972 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3973 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3974 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3975 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3976 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3977 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3978 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3979 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3980 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3981 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3982 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3983 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3984 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3985 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3986 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3987 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3988 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3989 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3990 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3991 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3992 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3993 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3994 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3995 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3996 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3997 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3998 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X3999 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4000 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4001 opamp_diego_4/vbn BarePad_17/PAD opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4002 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4003 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4004 opamp_diego_4/w_4660_n6791# BarePad_17/PAD opamp_diego_4/vbn opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4005 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4006 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4007 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4008 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4009 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4010 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4011 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4012 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4013 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4014 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4015 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4016 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4017 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4018 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4019 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4020 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4021 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4022 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4023 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4024 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4025 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4026 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4027 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4028 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4029 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4030 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4031 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4032 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4033 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4034 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4035 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4036 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4037 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4038 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4039 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4040 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4041 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4042 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4043 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4044 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4045 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4046 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4047 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4048 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4049 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4050 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4051 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4052 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4053 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4054 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4055 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4056 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4057 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4058 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4059 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4060 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4061 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4062 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4063 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4064 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4065 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4066 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4067 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4068 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4069 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4070 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4071 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4072 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4073 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4074 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4075 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4076 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4077 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4078 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4079 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4080 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4081 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4082 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4083 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4084 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4085 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4086 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4087 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4088 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4089 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4090 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4091 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4092 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4093 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4094 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4095 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4096 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4097 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4098 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4099 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4100 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4101 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4102 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4103 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4104 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4105 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4106 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4107 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4108 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4109 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4110 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4111 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4112 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4113 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4114 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4115 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4116 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4117 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4118 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4119 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4120 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4121 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4122 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4123 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4124 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4125 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4126 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4127 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4128 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4129 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4130 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4131 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4132 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4133 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4134 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4135 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4136 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4137 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4138 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4139 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4140 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4141 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4142 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4143 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4144 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4145 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4146 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4147 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4148 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4149 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4150 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4151 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4152 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4153 BarePad_17/PAD opamp_diego_4/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4154 vssa2 opamp_diego_4/voe1 BarePad_17/PAD vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4155 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4156 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4157 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4158 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4159 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4160 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4161 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4162 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4163 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4164 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4165 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4166 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4167 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4168 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4169 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4170 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4171 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4172 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4173 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4174 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4175 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4176 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4177 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4178 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4179 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4180 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4181 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4182 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4183 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4184 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4185 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4186 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4187 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4188 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4189 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4190 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4191 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4192 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4193 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4194 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4195 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4196 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4197 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4198 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4199 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4200 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4201 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4202 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4203 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4204 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4205 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4206 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4207 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4208 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4209 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4210 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4211 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4212 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4213 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4214 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4215 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4216 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4217 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4218 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4219 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4220 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4221 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4222 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4223 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4224 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4225 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4226 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4227 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4228 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4229 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4230 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4231 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4232 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4233 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4234 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4235 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4236 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4237 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4238 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4239 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4240 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4241 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4242 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4243 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4244 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4245 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4246 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4247 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4248 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4249 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4250 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4251 opamp_diego_4/voe1 opamp_diego_4/vin_p opamp_diego_4/w_4660_n6791# opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4252 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4253 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4254 opamp_diego_4/w_4660_n6791# opamp_diego_4/vin_p opamp_diego_4/voe1 opamp_diego_4/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4255 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=6.786e+13p pd=5.13245e+08u as=0p ps=0u w=3e+06u l=300000u
X4256 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4257 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4258 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4259 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4260 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4261 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4262 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4263 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4264 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4265 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4266 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4267 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4268 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4269 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4270 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4271 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4272 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4273 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4274 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4275 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4276 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4277 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4278 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4279 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4280 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4281 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4282 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4283 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4284 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4285 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4286 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4287 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4288 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4289 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4290 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4291 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4292 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4293 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4294 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4295 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4296 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4297 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4298 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4299 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4300 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4301 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4302 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4303 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4304 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4305 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4306 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4307 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4308 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4309 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4310 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4311 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4312 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4313 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4314 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4315 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4316 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4317 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4318 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4319 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4320 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4321 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4322 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4323 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4324 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4325 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4326 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4327 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4328 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4329 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4330 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4331 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4332 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4333 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4334 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4335 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4336 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4337 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4338 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4339 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4340 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4341 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4342 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4343 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4344 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4345 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4346 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4347 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4348 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4349 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4350 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4351 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4352 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4353 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4354 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4355 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4356 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4357 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4358 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4359 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4360 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4361 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4362 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4363 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4364 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4365 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4366 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4367 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4368 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4369 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4370 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4371 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4372 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4373 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4374 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4375 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4376 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4377 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4378 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4379 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4380 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4381 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4382 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4383 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4384 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4385 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4386 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4387 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4388 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4389 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4390 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4391 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4392 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4393 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4394 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4395 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4396 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4397 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4398 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4399 vccd1 gpio_noesd[10] gpio_noesd[9] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4400 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4401 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4402 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4403 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4404 gpio_noesd[9] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4405 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4406 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4407 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4408 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4409 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4410 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4411 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4412 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4413 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4414 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4415 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4416 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4417 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4418 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4419 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4420 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4421 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4422 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4423 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4424 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4425 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4426 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4427 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4428 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4429 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4430 vssa2 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4431 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4432 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4433 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4434 opamp_diego_5/vbn opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4435 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4436 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4437 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4438 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4439 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4440 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4441 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4442 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4443 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4444 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4445 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4446 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4447 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4448 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4449 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4450 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4451 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4452 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4453 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4454 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4455 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4456 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4457 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4458 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4459 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4460 vssa2 opamp_diego_5/vbn opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4461 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4462 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4463 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4464 opamp_diego_5/voe1 opamp_diego_5/vbn vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4465 gpio_noesd[9] opamp_diego_5/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X4466 gpio_noesd[9] opamp_diego_5/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X4467 gpio_noesd[9] opamp_diego_5/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X4468 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4469 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4470 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4471 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4472 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4473 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4474 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4475 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4476 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4477 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4478 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4479 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4480 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4481 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4482 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4483 gpio_noesd[10] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=6.96e+12p pd=5.264e+07u as=0p ps=0u w=3e+06u l=300000u
X4484 vccd1 gpio_noesd[10] gpio_noesd[10] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4485 vccd1 gpio_noesd[10] gpio_noesd[10] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4486 gpio_noesd[10] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4487 gpio_noesd[10] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4488 gpio_noesd[10] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4489 gpio_noesd[10] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4490 gpio_noesd[10] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4491 vccd1 gpio_noesd[10] gpio_noesd[10] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4492 vccd1 gpio_noesd[10] gpio_noesd[10] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4493 vccd1 gpio_noesd[10] gpio_noesd[10] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4494 vccd1 gpio_noesd[10] gpio_noesd[10] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4495 vccd1 gpio_noesd[10] gpio_noesd[10] vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4496 gpio_noesd[10] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4497 gpio_noesd[10] gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4498 gpio_noesd[9] opamp_diego_5/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X4499 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4500 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4501 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4502 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4503 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4504 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4505 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4506 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4507 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4508 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4509 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4510 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4511 vccd1 gpio_noesd[10] opamp_diego_5/w_4660_n6791# vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4512 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4513 opamp_diego_5/w_4660_n6791# gpio_noesd[10] vccd1 vccd1 sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4514 gpio_noesd[9] opamp_diego_5/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X4515 gpio_noesd[9] opamp_diego_5/a_10927_n7515# sky130_fd_pr__cap_mim_m3_1 l=1.5e+07u w=1.755e+07u
X4516 opamp_diego_5/a_10927_n7515# vccd1 opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X4517 opamp_diego_5/a_10927_n7515# vccd1 opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X4518 opamp_diego_5/a_10927_n7515# vccd1 opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X4519 opamp_diego_5/a_10927_n7515# vccd1 opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X4520 opamp_diego_5/a_10927_n7515# vccd1 opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X4521 opamp_diego_5/a_10927_n7515# vccd1 opamp_diego_5/voe1 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=750000u l=150000u
X4522 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4523 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4524 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4525 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4526 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4527 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4528 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4529 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4530 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4531 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4532 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4533 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4534 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4535 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4536 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4537 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4538 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4539 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4540 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4541 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4542 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4543 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4544 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4545 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4546 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4547 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4548 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4549 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4550 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4551 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4552 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4553 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4554 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4555 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4556 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4557 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4558 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4559 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4560 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4561 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4562 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4563 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4564 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4565 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4566 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4567 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4568 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4569 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4570 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4571 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4572 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4573 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4574 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4575 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4576 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4577 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4578 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4579 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4580 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4581 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4582 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4583 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4584 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4585 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4586 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4587 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4588 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4589 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4590 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4591 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4592 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4593 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4594 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4595 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4596 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4597 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4598 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4599 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4600 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4601 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4602 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4603 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4604 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4605 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4606 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4607 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4608 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4609 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4610 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4611 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4612 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4613 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4614 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4615 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4616 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4617 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4618 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4619 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4620 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4621 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4622 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4623 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4624 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4625 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4626 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4627 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4628 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4629 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4630 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4631 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4632 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4633 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4634 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4635 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4636 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4637 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4638 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4639 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4640 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4641 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4642 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4643 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4644 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4645 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4646 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4647 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4648 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4649 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4650 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4651 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4652 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4653 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4654 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4655 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4656 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4657 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4658 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4659 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4660 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4661 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4662 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4663 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4664 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4665 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4666 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4667 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4668 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4669 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4670 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4671 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4672 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4673 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4674 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4675 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4676 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4677 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4678 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4679 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4680 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4681 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4682 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4683 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4684 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4685 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4686 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4687 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4688 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4689 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4690 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4691 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4692 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4693 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4694 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4695 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4696 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4697 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4698 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4699 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4700 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4701 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4702 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4703 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4704 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4705 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4706 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4707 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4708 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4709 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4710 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4711 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4712 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4713 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4714 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4715 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4716 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4717 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4718 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4719 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4720 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4721 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4722 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4723 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4724 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4725 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4726 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4727 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4728 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4729 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4730 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4731 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4732 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4733 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4734 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4735 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4736 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4737 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4738 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4739 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4740 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4741 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4742 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4743 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4744 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4745 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4746 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4747 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4748 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4749 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4750 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4751 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4752 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4753 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4754 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4755 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4756 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4757 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4758 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4759 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4760 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4761 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4762 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4763 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4764 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4765 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4766 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4767 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4768 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4769 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4770 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4771 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4772 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4773 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4774 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4775 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4776 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4777 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4778 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4779 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4780 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4781 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4782 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4783 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4784 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4785 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4786 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4787 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4788 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4789 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4790 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4791 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4792 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4793 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4794 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4795 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4796 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4797 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4798 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4799 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4800 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4801 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4802 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4803 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4804 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4805 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4806 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4807 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4808 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4809 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4810 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4811 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4812 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4813 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4814 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4815 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4816 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4817 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4818 opamp_diego_5/vbn gpio_noesd[9] opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4819 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4820 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4821 opamp_diego_5/w_4660_n6791# gpio_noesd[9] opamp_diego_5/vbn opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4822 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.01155e+14p ps=7.52005e+08u w=4.5e+06u l=450000u
X4823 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4824 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4825 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4826 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4827 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4828 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4829 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4830 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4831 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4832 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4833 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4834 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4835 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4836 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4837 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4838 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4839 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4840 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4841 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4842 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4843 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4844 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4845 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4846 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4847 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4848 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4849 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4850 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4851 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4852 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4853 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4854 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4855 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4856 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4857 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4858 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4859 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4860 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4861 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4862 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4863 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4864 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4865 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4866 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4867 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4868 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4869 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4870 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4871 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4872 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4873 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4874 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4875 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4876 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4877 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4878 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4879 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4880 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4881 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4882 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4883 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4884 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4885 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4886 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4887 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4888 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4889 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4890 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4891 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4892 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4893 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4894 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4895 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4896 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4897 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4898 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4899 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4900 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4901 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4902 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4903 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4904 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4905 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4906 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4907 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4908 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4909 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4910 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4911 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4912 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4913 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4914 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4915 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4916 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4917 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4918 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4919 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4920 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4921 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4922 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4923 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4924 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4925 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4926 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4927 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4928 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4929 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4930 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4931 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4932 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4933 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4934 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4935 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4936 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4937 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4938 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4939 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4940 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4941 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4942 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4943 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4944 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4945 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4946 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4947 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4948 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4949 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4950 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4951 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4952 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4953 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4954 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4955 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4956 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4957 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4958 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4959 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4960 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4961 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4962 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4963 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4964 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4965 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4966 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4967 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4968 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4969 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4970 gpio_noesd[9] opamp_diego_5/voe1 vssa2 vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4971 vssa2 opamp_diego_5/voe1 gpio_noesd[9] vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.5e+06u l=450000u
X4972 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4973 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4974 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4975 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4976 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4977 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4978 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4979 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4980 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4981 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4982 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4983 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4984 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4985 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4986 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4987 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4988 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4989 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4990 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4991 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4992 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4993 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4994 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4995 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4996 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4997 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4998 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X4999 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5000 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5001 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5002 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5003 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5004 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5005 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5006 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5007 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5008 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5009 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5010 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5011 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5012 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5013 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5014 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5015 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5016 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5017 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5018 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5019 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5020 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5021 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5022 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5023 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5024 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5025 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5026 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5027 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5028 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5029 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5030 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5031 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5032 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5033 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5034 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5035 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5036 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5037 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5038 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5039 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5040 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5041 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5042 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5043 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5044 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5045 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5046 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5047 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5048 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5049 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5050 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5051 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5052 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5053 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5054 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5055 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5056 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5057 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5058 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5059 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5060 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5061 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5062 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5063 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5064 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5065 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5066 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5067 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5068 opamp_diego_5/voe1 opamp_diego_5/vin_p opamp_diego_5/w_4660_n6791# opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5069 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5070 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5071 opamp_diego_5/w_4660_n6791# opamp_diego_5/vin_p opamp_diego_5/voe1 opamp_diego_5/w_4660_n6791# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=300000u
X5072 vssa2 BarePad_16/PAD opamp_diego_3/vin_p vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=2e+06u
R0 vccd1 io_clamp_high[0] 0.000000
R1 vccd1 io_clamp_high[1] 0.000000
R2 vssa2 vssd1 0.000000
X5073 io_analog[4] opamp_diego_4/vin_p sky130_fd_pr__cap_mim_m3_1 l=7.5e+06u w=7.5e+06u
X5074 vssa2 gpio_analog[14] opamp_diego_5/vin_p vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+07u
X5075 io_analog[1] opamp_diego_3/vin_p sky130_fd_pr__cap_mim_m3_1 l=7.5e+06u w=7.5e+06u
X5076 vssa2 BarePad_8/PAD opamp_diego_1/vin_p vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+07u
X5077 gpio_analog[6] opamp_diego_2/vin_p sky130_fd_pr__cap_mim_m3_1 l=3.15e+06u w=3.15e+06u
X5078 gpio_analog[12] opamp_diego_5/vin_p sky130_fd_pr__cap_mim_m3_1 l=3.15e+06u w=3.15e+06u
X5079 vssa2 BarePad_12/PAD opamp_diego_2/vin_p vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+07u
X5080 gpio_analog[4] opamp_diego_1/vin_p sky130_fd_pr__cap_mim_m3_1 l=7.5e+06u w=7.5e+06u
R3 vssa2 vssa1 0.000000
R4 vssa2 io_clamp_low[1] 0.000000
X5081 vssa2 BarePad_20/PAD opamp_diego_4/vin_p vssa2 sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=2e+06u
R5 vssa2 io_clamp_low[0] 0.000000
XBarePad_12 BarePad_12/PAD sky130_ef_io__bare_pad
XBarePad_5 BarePad_5/PAD sky130_ef_io__bare_pad
XBarePad_13 BarePad_13/PAD sky130_ef_io__bare_pad
XBarePad_6 BarePad_6/PAD sky130_ef_io__bare_pad
XBarePad_7 BarePad_7/PAD sky130_ef_io__bare_pad
XBarePad_14 BarePad_14/PAD sky130_ef_io__bare_pad
XBarePad_8 BarePad_8/PAD sky130_ef_io__bare_pad
XBarePad_15 BarePad_15/PAD sky130_ef_io__bare_pad
XBarePad_9 BarePad_9/PAD sky130_ef_io__bare_pad
XBarePad_17 BarePad_17/PAD sky130_ef_io__bare_pad
XBarePad_16 BarePad_16/PAD sky130_ef_io__bare_pad
XBarePad_18 BarePad_18/PAD sky130_ef_io__bare_pad
XRingOsl_v0_3stage_1/InverterBlock_0 gpio_noesd[1] sky130_fd_sc_hs__buf_16_1/A sky130_fd_sc_hs__buf_16_1/A
+ gpio_noesd[0] RingOsl_v0_3stage_1/InverterBlock_1/VIN RingOsl_v0_3stage_1/InverterBlock_1/VIP
+ InverterBlock
XRingOsl_v0_3stage_1/InverterBlock_1 gpio_noesd[1] RingOsl_v0_3stage_1/InverterBlock_1/VIN
+ RingOsl_v0_3stage_1/InverterBlock_1/VIP gpio_noesd[0] RingOsl_v0_3stage_1/InverterBlock_2/VIN
+ RingOsl_v0_3stage_1/InverterBlock_2/VIP InverterBlock
XRingOsl_v0_3stage_1/InverterBlock_2 gpio_noesd[1] RingOsl_v0_3stage_1/InverterBlock_2/VIN
+ RingOsl_v0_3stage_1/InverterBlock_2/VIP gpio_noesd[0] sky130_fd_sc_hs__buf_16_1/A
+ sky130_fd_sc_hs__buf_16_1/A InverterBlock
XBarePad_19 BarePad_19/PAD sky130_ef_io__bare_pad
XComparatorQpixLayout_0 gpio_analog[8] gpio_analog[7] io_analog[9] io_analog[8] ComparatorQpixLayout_0/OUT
+ ComparatorQpixLayout
Xclassic-opamp_0 opamp_diego_0/vin_p BarePad_3/PAD BarePad_1/PAD BarePad_2/PAD classic-opamp
Xclassic-opamp_1 opamp_diego_1/vin_p BarePad_7/PAD gpio_analog[5] gpio_analog[4] classic-opamp
Xclassic-opamp_2 opamp_diego_2/vin_p BarePad_11/PAD io_analog[0] gpio_analog[6] classic-opamp
Xmosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_9/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_10/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_11/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_12/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_13/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_14/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_15/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_16/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_17/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_18/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_19/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_5/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_6/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_7/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_0 mosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_1 mosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_2 mosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_3 mosarray_0/pmosLVTarray2_0/BarePadArray_8/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_0/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_1/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_2/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_3/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_5/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_4/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_6/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_7/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_8/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_2
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_3/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_3/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_3/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_3/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_4/BarePad_0
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_4/BarePad_1
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_4/BarePad_2
+ vssa2 sky130_ef_io__bare_pad
Xmosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_4/BarePad_3
+ mosarray_0/nmosLVTarray_0/BarePadArray10x10_0/BarePadArray1x10_9/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_7/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_8/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_9/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_0/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_1/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_2/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_3/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_4/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_6/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_1/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_0/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_2/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_3/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_0 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_0/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_1 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_1/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_2 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_2/PAD
+ sky130_ef_io__bare_pad
Xmosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_3 mosarray_0/pmosLVTarray1_0/BarePadArray1x5_5/BarePadArray_4/BarePad_3/PAD
+ sky130_ef_io__bare_pad
Xclassic-opamp_3 opamp_diego_3/vin_p BarePad_15/PAD io_analog[2] io_analog[1] classic-opamp
Xclassic-opamp_4 opamp_diego_4/vin_p BarePad_19/PAD io_analog[5] io_analog[4] classic-opamp
Xsky130_fd_sc_hs__buf_16_0 sky130_fd_sc_hs__buf_16_1/A vssa2 vccd1 gpio_noesd[3] sky130_fd_sc_hs__buf_16
Xsky130_fd_sc_hs__buf_16_1 sky130_fd_sc_hs__buf_16_1/A vssa2 vccd1 gpio_noesd[2] sky130_fd_sc_hs__buf_16
Xclassic-opamp_5 opamp_diego_5/vin_p classic-opamp_5/Bias1 gpio_analog[13] gpio_analog[12]
+ classic-opamp
Xsky130_fd_sc_hs__buf_16_2 ComparatorQpixLayout_0/OUT vssa2 vccd1 io_analog[10] sky130_fd_sc_hs__buf_16
XBarePad_0 BarePad_0/PAD sky130_ef_io__bare_pad
XBarePad_1 BarePad_1/PAD sky130_ef_io__bare_pad
XBarePad_20 BarePad_20/PAD sky130_ef_io__bare_pad
XBarePad_2 BarePad_2/PAD sky130_ef_io__bare_pad
XBarePad_10 BarePad_10/PAD sky130_ef_io__bare_pad
XBarePad_3 BarePad_3/PAD sky130_ef_io__bare_pad
XBarePad_11 BarePad_11/PAD sky130_ef_io__bare_pad
XBarePad_4 BarePad_4/PAD sky130_ef_io__bare_pad
.ends
